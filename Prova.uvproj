# Keil uVision project Prova.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: Prova +hex
  c flags: Optimize=8
  group Source Group 1
    ./: prova.c
